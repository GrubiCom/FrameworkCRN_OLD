<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>spectrum_mobitily</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>spectrum_mobitily</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>Get_Power</key>
<param><key>id</key><value>Get_Power_0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>ccc</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>flag</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>check_channel</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_2</value></param>
<param><key>label</key><value>signal</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pmt_cpp_set_ccc</key>
<param><key>id</key><value>pmt_cpp_set_ccc_0</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>pmt_cpp_set_ccc_0</sink_block_id><source_key>out</source_key><sink_key>flag</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>Get_Power_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_2</source_block_id><sink_block_id>Get_Power_0</sink_block_id><source_key>out</source_key><sink_key>in_pdu</sink_key></connection>
<connection><source_block_id>pmt_cpp_set_ccc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>ccc</source_key><sink_key>in</sink_key></connection>
</flow_graph>
