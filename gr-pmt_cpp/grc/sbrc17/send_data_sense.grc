<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>send_data_sense</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>send_data_sense</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>message</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>repeat_message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>Ack</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>file_ready</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pmt_cpp_ACK</key>
<param><key>id</key><value>pmt_cpp_ACK_0</value></param>
</block>
<block>
<key>pmt_cpp_wait_first_ack</key>
<param><key>id</key><value>pmt_cpp_wait_first_ack_0</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>pmt_cpp_ACK_0</sink_block_id><source_key>out</source_key><sink_key>Ack</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>pmt_cpp_ACK_0</sink_block_id><source_key>out</source_key><sink_key>File_Ready</sink_key></connection>
<connection><source_block_id>pmt_cpp_ACK_0</source_block_id><sink_block_id>pmt_cpp_wait_first_ack_0</sink_block_id><source_key>first</source_key><sink_key>fisrt_message</sink_key></connection>
<connection><source_block_id>pmt_cpp_ACK_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>msg</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pmt_cpp_wait_first_ack_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>message_repeat</source_key><sink_key>in</sink_key></connection>
</flow_graph>
