<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Cog_sense</value></param>
<param><key>author</key><value>Ariel Marques</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Cognitive network over IEEE 802.15.4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>1000e3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>89</value></param>
<param><key>label</key><value>79</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>File_Recorder</key>
<param><key>id</key><value>File_Recorder_0</value></param>
</block>
<block>
<key>Get_Power</key>
<param><key>id</key><value>Get_Power_0</value></param>
</block>
<block>
<key>IEEE_802_15_4</key>
<param><key>id</key><value>IEEE_802_15_4_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>cog_802_15_4</key>
<param><key>id</key><value>cog_802_15_4_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>json_file</key>
<param><key>id</key><value>json_file_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>pmt_cpp_ACK</key>
<param><key>id</key><value>pmt_cpp_ACK_0</value></param>
</block>
<block>
<key>pmt_cpp_file_connect</key>
<param><key>id</key><value>pmt_cpp_file_connect_0</value></param>
</block>
<block>
<key>pmt_cpp_pmt_extract2</key>
<param><key>id</key><value>pmt_cpp_pmt_extract2_0</value></param>
</block>
<block>
<key>pmt_cpp_send_file_ACK</key>
<param><key>id</key><value>pmt_cpp_send_file_ACK_2</value></param>
</block>
<block>
<key>pmt_cpp_set_ccc</key>
<param><key>id</key><value>pmt_cpp_set_ccc_0</value></param>
</block>
<block>
<key>pmt_cpp_start_sense</key>
<param><key>id</key><value>pmt_cpp_start_sense_0</value></param>
</block>
<block>
<key>pmt_cpp_start_share</key>
<param><key>id</key><value>pmt_cpp_start_share_0</value></param>
</block>
<block>
<key>pmt_cpp_transmission_data</key>
<param><key>id</key><value>pmt_cpp_transmission_data_0</value></param>
</block>
<block>
<key>pmt_cpp_wait_first_ack</key>
<param><key>id</key><value>pmt_cpp_wait_first_ack_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>bw</value></param>
<param><key>center_freq0</key><value>6000000000</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>bw</value></param>
<param><key>center_freq0</key><value>6000000000</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>File_Recorder_0</source_block_id><sink_block_id>pmt_cpp_send_file_ACK_2</sink_block_id><source_key>file_ready</source_key><sink_key>file_ready</sink_key></connection>
<connection><source_block_id>IEEE_802_15_4_0</source_block_id><sink_block_id>pmt_cpp_pmt_extract2_0</sink_block_id><source_key>rxout</source_key><sink_key>in_pdu</sink_key></connection>
<connection><source_block_id>IEEE_802_15_4_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cog_802_15_4_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cog_802_15_4_0</source_block_id><sink_block_id>pmt_cpp_pmt_extract2_0</sink_block_id><source_key>rxout</source_key><sink_key>in_pdu</sink_key></connection>
<connection><source_block_id>json_file_0</source_block_id><sink_block_id>pmt_cpp_send_file_ACK_2</sink_block_id><source_key>file_ready</source_key><sink_key>file_ready</sink_key></connection>
<connection><source_block_id>pmt_cpp_ACK_0</source_block_id><sink_block_id>pmt_cpp_wait_first_ack_0</sink_block_id><source_key>first</source_key><sink_key>fisrt_message</sink_key></connection>
<connection><source_block_id>pmt_cpp_ACK_0</source_block_id><sink_block_id>IEEE_802_15_4_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pmt_cpp_ACK_0</source_block_id><sink_block_id>cog_802_15_4_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pmt_cpp_file_connect_0</source_block_id><sink_block_id>File_Recorder_0</sink_block_id><source_key>bool</source_key><sink_key>in_pdu</sink_key></connection>
<connection><source_block_id>pmt_cpp_file_connect_0</source_block_id><sink_block_id>json_file_0</sink_block_id><source_key>bool</source_key><sink_key>in_pdu</sink_key></connection>
<connection><source_block_id>pmt_cpp_file_connect_0</source_block_id><sink_block_id>File_Recorder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pmt_cpp_file_connect_0</source_block_id><sink_block_id>json_file_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pmt_cpp_file_connect_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pmt_cpp_pmt_extract2_0</source_block_id><sink_block_id>pmt_cpp_ACK_0</sink_block_id><source_key>Ack</source_key><sink_key>Ack</sink_key></connection>
<connection><source_block_id>pmt_cpp_pmt_extract2_0</source_block_id><sink_block_id>IEEE_802_15_4_0</sink_block_id><source_key>info_neighbor</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pmt_cpp_pmt_extract2_0</source_block_id><sink_block_id>pmt_cpp_start_sense_0</sink_block_id><source_key>sense</source_key><sink_key>pmt::dict</sink_key></connection>
<connection><source_block_id>pmt_cpp_pmt_extract2_0</source_block_id><sink_block_id>pmt_cpp_start_share_0</sink_block_id><source_key>share</source_key><sink_key>pmt::dict</sink_key></connection>
<connection><source_block_id>pmt_cpp_send_file_ACK_2</source_block_id><sink_block_id>pmt_cpp_ACK_0</sink_block_id><source_key>pdu</source_key><sink_key>File_Ready</sink_key></connection>
<connection><source_block_id>pmt_cpp_set_ccc_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>ccc</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_set_ccc_0</source_block_id><sink_block_id>uhd_usrp_source_0</sink_block_id><source_key>ccc</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_sense_0</source_block_id><sink_block_id>File_Recorder_0</sink_block_id><source_key>bool</source_key><sink_key>bool</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_sense_0</source_block_id><sink_block_id>json_file_0</sink_block_id><source_key>bool</source_key><sink_key>bool</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_sense_0</source_block_id><sink_block_id>pmt_cpp_file_connect_0</sink_block_id><source_key>bool</source_key><sink_key>in_pdu</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_sense_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>pmt::mp</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_sense_0</source_block_id><sink_block_id>uhd_usrp_source_0</sink_block_id><source_key>pmt::mp</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_share_0</source_block_id><sink_block_id>IEEE_802_15_4_0</sink_block_id><source_key>bool</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_share_0</source_block_id><sink_block_id>pmt_cpp_set_ccc_0</sink_block_id><source_key>bool</source_key><sink_key>flag</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_share_0</source_block_id><sink_block_id>pmt_cpp_transmission_data_0</sink_block_id><source_key>bool</source_key><sink_key>signal_in</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_share_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>pmt::mp</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_start_share_0</source_block_id><sink_block_id>uhd_usrp_source_0</sink_block_id><source_key>pmt::mp</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>pmt_cpp_transmission_data_0</source_block_id><sink_block_id>IEEE_802_15_4_0</sink_block_id><source_key>packet</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>pmt_cpp_transmission_data_0</source_block_id><sink_block_id>Get_Power_0</sink_block_id><source_key>signal_out</source_key><sink_key>in_pdu</sink_key></connection>
<connection><source_block_id>pmt_cpp_wait_first_ack_0</source_block_id><sink_block_id>IEEE_802_15_4_0</sink_block_id><source_key>message_repeat</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>Get_Power_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>IEEE_802_15_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>cog_802_15_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>pmt_cpp_file_connect_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
